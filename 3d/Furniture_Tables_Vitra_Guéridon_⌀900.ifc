Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-06-19T17:07:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 19 17:07:10 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{3C02ACD9-2881-4FEE-A1F6-C4F81609DB7F}\ifc * Database version: 5507 * Database creation date: Fri Jun 19 17:07:08 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 19 17:07:09 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 19 17:07:09 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Guéridon - Ø900, Furniture_Tables_Vitra_Guéridon_⌀900:Guéridon - Ø900:343237
In: Level 1
Type - Material: Deep black powder-coated 12, Solid American walnut 75
Type - General(Type) - Author: Convergo AB; BIMObjectName: Furniture_Tables_Vitra_Guéridon_⌀900; ConvergoRefNr: 0089-2006-0013-CH; ManufacturerName: Vitra; ManufacturerURL: www.vitra.com; NBSDescription: Tables; NBSReference: 45-35-86/327; ProductInformation: The Guéridon table, which was produced by the designer and engineer Jean Prouvé for the University of Paris, is a convincing demonstration of clear structural principles. This wooden table is a variation of Prouvé's architecturally informed design vocabulary in a natural material, proving that modern tables do not have to be made out of steel and glass.; Revision: n/a; Uniclass2: Pr_40_50_21_58; Uniclass2015Description: Occasional tables; Uniclass2015Reference: Pr_40_50_21_58; Version: 1; VersionDate: 17/06/2020
Type - Identity Data(Type) - Cost: 0; Description: The Guéridon table, which was produced by the designer and engineer Jean Prouvé for the University of Paris, is a convincing demonstration of clear structural principles. This wooden table is a variation of Prouvé's architecturally informed design vocabulary in a natural material, proving that modern tables do not have to be made out of steel and glass.; Design: Jean Prouvé, 1949; Manufacturer: Vitra; Model: Guéridon - Ø900; OmniClass Number: 23.40.20.14.17.24; OmniClass Title: Coffee Tables; Product Datasheet: https://www.vitra.com/en-tr/_storage/asset/191379/storage/master/download/FS_Gueridon-EN_Preview-Single-Page.pdf; Type Name: Guéridon - Ø900; URL: https://www.vitra.com/en-tr/product/gueridon
Type - Materials and Finishes(Type) - TableSecondaryMaterial: Deep black powder-coated 12
Type - Other(Type) - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Wooden; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Furniture_Tables_Vitra_Guéridon_⌀900; Features: n/a; Finish: Oiled finish; Grade: n/a; Material: Oak, walnut, steel; ModelNumber: 09156502; ModelReference: n/a; Name: Vitra_Guéridon_⌀900; ReplacementCost: n/a; Shape: Sculptured; Size: 900x900x740 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 2.1422 m2; Volume: 0.59948 m3
Materials and Finishes - TableMainMaterial: Solid American walnut 75
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Furniture_Tables_Vitra_Guéridon_⌀900: Guéridon - Ø900; Family and Type: Furniture_Tables_Vitra_Guéridon_⌀900: Guéridon - Ø900; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Tables_Vitra_Guéridon_⌀900: Guéridon - Ø900; Type Id: Furniture_Tables_Vitra_Guéridon_⌀900: Guéridon - Ø900; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
